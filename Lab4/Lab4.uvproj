# Keil uVision project Lab4.uvproj, settings and files
target Lab4 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab4
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s osasm.s cr4_fft_64_stm32.s PID_stm32.s UART.c os.c PLL.c ADCT0ATrigger.c cmdline.c FIFO.c ST7735.c UART_FIFO.c Lab4.c cmdline.h cr4_fft_1024_stm32.s
